PACKAGECONFIG:append = " networkd resolved"
RDEPENDS:${PN}:append = " wpa-supplicant "
# PACKAGECONFIG:remove = " networkd resolved"